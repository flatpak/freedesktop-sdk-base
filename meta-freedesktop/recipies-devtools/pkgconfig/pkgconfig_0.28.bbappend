EXTRA_OECONF = "--with-internal-glib"
