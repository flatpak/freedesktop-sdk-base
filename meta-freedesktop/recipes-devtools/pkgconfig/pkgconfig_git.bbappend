EXTRA_OECONF = "--with-internal-glib"
# We want the ability to override .pc variables
SRCREV = "ae0a8b1ad5e40f68fc09ffedac215e038a50f070"
