PACKAGECONFIG_append_class-target = " python"
