EXTRA_OECONF = "--enable-unicode-properties"
