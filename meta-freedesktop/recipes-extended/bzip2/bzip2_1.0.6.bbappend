FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
PR = "r6"
