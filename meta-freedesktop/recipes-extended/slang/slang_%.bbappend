CACHED_CONFIGUREVARS += "ac_cv_path_nc5config=no "
EXTRA_OECONF += " --with-x=no "
