
# Disable the nasm-native dependency on arm targets
#
DEPENDS_remove_aarch64 = " nasm-native"
DEPENDS_remove_arm = " nasm-native"
